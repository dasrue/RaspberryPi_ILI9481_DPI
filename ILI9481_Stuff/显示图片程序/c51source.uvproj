# Keil uVision project c51source.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: c51source +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: c51source.c GB1616.h GB3232.h
